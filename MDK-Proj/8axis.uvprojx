# Keil uVision project 8axis.uvprojx, settings and files
target 8axis (6120000::V6.12::.\ARMCLANG)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 8axis +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Src\App;..\Src\Config;..\Src\drv;..\Src\Tool;..\LIB;..\Src\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../Src/App/: AppErr.c AppInit.c Err.c FSM.c Logic.c MainTask.c Reset.c Teach.c
  group drv
    ../Src/drv/: DisDriver.c
  group common
    ../Src/common/: common.c
  group tool
    ../Src/Tool/: AxisMove.c UserTool.c
  group config
    ../Src/Config/: AxisConfig.c bsp_config.c InterLayer.c main.c
  group lib.startup
    ../LIB/: startup_stm32f40_41xxx.s
  group lib
    ../LIB/: Al.lib BI.lib BS.lib
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0
